# Keil uVision project IO-LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: OUT_STC51_Hex +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\delay;.\GPIO;.\LED;.\OLED;.\Gyro;.\Uart1;.\STEP_MOTOR;.\TRAFFIC_LIGHT;.\delay;.\PULSE;.\KEY;.\MKEY;.\BMKEY;.\YBUZZER;.\WBUZZER;.\ONELED
  group Source Group 1
    ./: main.c
    ./GPIO/: GPIO.c
    ./LED/: LED.c
    ./delay/: delay.c
    ./PULSE/: PULSE_IN_BIT_OUT.c
    ./KEY/: KEY.c
    ./MKEY/: MKEY.c
    ./BMKEY/: BMKEY.c
    ./YBUZZER/: YBUZZER.c
    ./WBUZZER/: WBUZZER.c
    ./ONELED/: ONELED.c
